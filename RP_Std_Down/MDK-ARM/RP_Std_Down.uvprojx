# Keil uVision project RP_Std_Down.uvprojx, settings and files
target RP_Std_Down (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RP_Std_Down +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__CC_ARM,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/ProtocolLayer;../Application/DriverLayer;../Application/ConfigLayer;../Application/DeviceLayer;../Application/DeviceLayer/Imu;../Application/DeviceLayer/Sensor;../Application/AlgorithmLayer;../Drivers/CMSIS/DSP/Include;../Application/ModuleLayer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Algorithm
    ../Application/AlgorithmLayer/: ave_filter.c rp_math.c crc.c
  group Control
    ../Application/ControlLayer/: control.c
  group Config
    ../Application/ConfigLayer/: rp_config.c rp_config.h rp_device_config.h rp_driver_config.h rp_user_config.h
  group Module
    ../Application/ModuleLayer/: judge.c
  group Protocol
    ../Application/ProtocolLayer/: can_protocol.c imu_protocol.c rm_protocol.c judge_protocol.c up_com_protocol.c
  group Device
    ../Application/DeviceLayer/: device.c
    ../Application/DeviceLayer/Sensor/: imu_sensor.c
  group Driver/Imu
    ../Application/DeviceLayer/Imu/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c soft_iic.c
  group Driver
    ../Application/DriverLayer/: driver.c drv_can.c drv_uart.c drv_haltick.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0

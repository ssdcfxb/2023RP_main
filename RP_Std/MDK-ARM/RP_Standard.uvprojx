# Keil uVision project RP_Standard.uvprojx, settings and files
target RP_Standard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RP_Standard +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__CC_ARM,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/DriverLayer;../Application/Task;../Application/ModuleLayer;../Application/DeviceLayer/Imu;../Application/DeviceLayer/Motor;../Application/DeviceLayer/Sensor;../Application/DeviceLayer;../Application/ConfigLayer;../Application/ProtocolLayer;../Application/AlgorithmLayer
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/Config
    ../Application/ConfigLayer/: rp_config.c rp_config.h rp_user_config.h rp_device_config.h rp_driver_config.h
  group Application/Algorithm
    ../Application/AlgorithmLayer/: PID.c ave_filter.c crc.c rp_math.c pid_conf.h
  group Application/Task
    ../Application/Task/: LED_task.c System_task.c Ctrl_task.c Monitor_task.c Project_log.txt
  group Application/Module
    ../Application/ModuleLayer/: chassis.c gimbal.c shoot.c judge.c
  group Application/Protocol
    ../Application/ProtocolLayer/: can_protocol.c imu_protocol.c vision_protocol.c rc_protocol.c rm_protocol.c rm_protocol.h
  group Application/Device/Imu
    ../Application/DeviceLayer/Imu/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c soft_iic.c
  group Application/Device
    ../Application/DeviceLayer/Sensor/: imu_sensor.c rc_sensor.c vision_sensor.c
    ../Application/DeviceLayer/Motor/: motor_2006.c motor_3508.c motor_6020.c
    ../Application/DeviceLayer/: device.c
  group Application/Driver
    ../Application/DriverLayer/: drv_can.c drv_uart.c drv_haltick.c driver.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0
